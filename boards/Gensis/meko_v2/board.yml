## boards/Gensis/meko_v2/board.yml
```yaml
board:
  name: meko_v2
  full_name: Meko V2
  vendor: Gensis
  socs:
  - name: nrf5340
    variants:
    - name: ns
      cpucluster: cpuapp
```
